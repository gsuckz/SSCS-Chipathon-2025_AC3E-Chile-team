v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 80 -40 160 -40 {lab=S}
N 80 -40 80 10 {lab=S}
N 280 -60 280 -30 {lab=#net1}
N 280 10 280 30 {lab=#net2}
C {gf180mcu_fd_sc_mcu9t5v0_symbols/nand2_1.sym} 220 -60 0 0 {name=x1 VGND=VSS VNB=VCC VPB=VSS VPWR=VCC prefix=gf180mcu_fd_sc_mcu9t5v0__ }
C {devices/iopin.sym} 250 120 2 0 {name=p4 lab=VCC}
C {devices/iopin.sym} 250 160 2 0 {name=p5 lab=VSS}
C {gf180mcu_fd_sc_mcu9t5v0_symbols/inv_1.sym} 120 10 0 0 {name=x3 VGND=VSS VNB=VCC VPB=VSS VPWR=VCC  prefix=gf180mcu_fd_sc_mcu9t5v0__ }
C {devices/iopin.sym} 160 -80 2 0 {name=p1 lab=A}
C {devices/iopin.sym} 160 50 2 0 {name=p2 lab=B}
C {devices/iopin.sym} 400 -10 2 1 {name=p3 lab=Y}
C {devices/iopin.sym} 80 -20 2 0 {name=p6 lab=S}
C {gf180mcu_fd_sc_mcu9t5v0_symbols/nand2_1.sym} 220 30 0 0 {name=x2 VGND=VSS VNB=VCC VPB=VSS VPWR=VCC prefix=gf180mcu_fd_sc_mcu9t5v0__ }
C {gf180mcu_fd_sc_mcu9t5v0_symbols/nand2_1.sym} 340 -10 0 0 {name=x4 VGND=VSS VNB=VCC VPB=VSS VPWR=VCC prefix=gf180mcu_fd_sc_mcu9t5v0__ }
